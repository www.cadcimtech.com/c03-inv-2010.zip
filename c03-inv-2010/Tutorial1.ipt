# Autodesk Inventor part: Tutorial1
## iProperties
Created: 2008-01
Part Number: Tutorial1
Document SubType Name: Modeling
Designer: CADSoft
Density: 1 g/cm^3
Author: CADSoft
